<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_vel_doppler</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>value</key><value>145.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>145.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>velocity</value></param>
<param><key>value</key><value>17000.0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gpredict_MsgPairToVar</key>
<param><key>id</key><value>gpredict_MsgPairToVar_0</value></param>
<param><key>target</key><value>doppler_freq</value></param>
</block>
<block>
<key>gpredict_vel_doppler</key>
<param><key>id</key><value>gpredict_vel_doppler_0</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>gpredict_port</key><value>7356</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>velocity</key><value>velocity</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>key</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gpredict_vel_doppler_0</source_block_id><sink_block_id>analog_sig_source_x_0</sink_block_id><source_key>freqshift</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>gpredict_vel_doppler_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>freqshift</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gpredict_vel_doppler_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>frequency</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gpredict_vel_doppler_0</source_block_id><sink_block_id>gpredict_MsgPairToVar_0</sink_block_id><source_key>frequency</source_key><sink_key>inpair</sink_key></connection>
<connection><source_block_id>gpredict_vel_doppler_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>frequency</source_key><sink_key>val</sink_key></connection>
</flow_graph>
