<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>complex_gpredict_state</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>False</value></param>
<param><key>basedir</key><value>/tmp</value></param>
<param><key>basefile</key><value>gr_record</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>radioCenterFreq</key><value>freq</value></param>
<param><key>honorFreqChange</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>filerepeater_StateAnd</key>
<param><key>id</key><value>filerepeater_StateAnd_0</value></param>
</block>
<block>
<key>gpredict_MsgPairToVar</key>
<param><key>id</key><value>gpredict_MsgPairToVar_0</value></param>
<param><key>target</key><value>freq</value></param>
</block>
<block>
<key>gpredict_azel_limit</key>
<param><key>id</key><value>gpredict_azel_limit_0</value></param>
<param><key>az_max</key><value>20.0</value></param>
<param><key>el_max</key><value>60.0</value></param>
<param><key>az_min</key><value>240.0</value></param>
<param><key>el_min</key><value>10.0</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_port</key><value>7356</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>gpredict_rotor</key>
<param><key>id</key><value>gpredict_rotor_0</value></param>
<param><key>gpredict_port</key><value>4533</value></param>
<param><key>gpredict_host</key><value>localhost</value></param>
<param><key>minEl</key><value>20.0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>key</key><value>state</value></param>
<param><key>label</key><value>State</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>state</source_key><sink_key>recordstate</sink_key></connection>
<connection><source_block_id>filerepeater_StateAnd_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>state</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>gpredict_azel_limit_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>state</source_key><sink_key>state2</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>gpredict_MsgPairToVar_0</sink_block_id><source_key>freq</source_key><sink_key>inpair</sink_key></connection>
<connection><source_block_id>gpredict_doppler_0</source_block_id><sink_block_id>filerepeater_StateAnd_0</sink_block_id><source_key>state</source_key><sink_key>state1</sink_key></connection>
<connection><source_block_id>gpredict_rotor_0</source_block_id><sink_block_id>gpredict_azel_limit_0</sink_block_id><source_key>az_el</source_key><sink_key>az_el</sink_key></connection>
</flow_graph>
