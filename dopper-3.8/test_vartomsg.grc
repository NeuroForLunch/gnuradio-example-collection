options:
  parameters:
    generate_options: qt_gui
    id: test_vartomsg
    output_language: python
    title: Test Var to Message
  states: {}

blocks:
- name: freq
  id: guiextra_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: ','
    lbl: Frequency
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    outputmsgname: freq
    readOnly: 'False'
    relBackgroundColor: black
    relFontColor: white
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: gpredict_VarToMsg_0
  id: gpredict_VarToMsg
  parameters:
    msgname: freq
    target: freq
  states: {}

connections:
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [gpredict_VarToMsg_0, msgout, blocks_message_debug_0, print]

metadata:
  file_format: 1
